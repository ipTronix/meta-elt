COMPATIBLE_MACHINE_av108 = "av108"
