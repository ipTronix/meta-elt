UBRANCH = "av108_integration"
SRC_URI = "git://github.com/ApisSys/u-boot-xlnx-ap6.git;protocol=git;branch=${UBRANCH}"
SRC_URI[md5sum] = "025bf9f768cbcb1a165dbe1a110babfb"
SRCREV = "av108_integration"
LICENSE = "GPLv2+"
LIC_FILES_CHKSUM = "file://Licenses/README;md5=025bf9f768cbcb1a165dbe1a110babfb"

